# Keil uVision project 8051_PLC_MINI.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC11F16XE STC-STC11
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FFF) CLOCK(45000000) MODP2
  output: 8051_PLC_MINI +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 main.c
